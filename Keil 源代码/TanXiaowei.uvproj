# Keil uVision project TanXiaowei.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: TanXiaowei +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Keil 源代码 - 副本
  group Source Group 1
    ./: STARTUP.A51 Tanxiaowei.c Display.c Motor.c lcd.c Sensor.c include.c Usart.c
